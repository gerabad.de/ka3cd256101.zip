Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: x:/temp/worker_COMMON_576/temp/tmp_1656_36_aZ4jU/format_0/3259(architecture=300).ifc
Time: 2025-09-01T09:05:29
Made in: PARTsolutions

# IfcProject, 3259(architecture=300)
Description: ALUVIA

# IfcDiscreteAccessory, 3259(architecture=300)
In: BUILDING
Description: 3259(architecture=300)
Pset_ManufacturerTypeInformation - Manufacturer: KALDEWEI; ArticleNumber: 3259
ePset_PARTsolutions - NB: 3259(architecture=300); NN: 3259; NT: ALUVIA; NBSYN: $A.($LODDEST.=$LODLEVEL.); LINA: 3259(architecture=300); CATALOG: Kaldewei; LODLEVEL: 300; A: 3259; B: 3259_aluvia_800x900.png; C: ALUVIA; E: KALDEWEI; EF000049: 800; EF004567: 900; etim7_EC003246: EC003246; etim7_EC003246_WIDTH: 900; etim7_EC003246_LENGTH: 800
